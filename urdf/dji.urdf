Commit message: Add modified urdf for tello

File: urdf/dji.urdf (robot description, URDF)
Before this commit: robot DJI_Matrice_100, 1 links, 0 joints
Links:
- link robot_base_link: geometry visual mesh filename=package://ars_robot_models/meshes/djiTello.dae scale=0.05 0.05 0.05
